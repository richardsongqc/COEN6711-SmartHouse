# IAR project USB_DFU.ewp, settings and files
configuration Flash Debug KL2 (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX128xxx5 Freescale MK20DX128xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR
  ICCARM.CCDiagSuppress: Pa082,Pe191,Pe186,Pe550,Pe177,Pa039,Pe223
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\flash_driver; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: USB_DFU.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\MKL25Z128VLK_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: derivative.h readme.txt
  group app
    ../../: Boot_loader_task.c Bootloader.h dfu_mouse.c Loader.c usb_descriptor.c
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: printf.c RealTimerCounter_kinetis.c sci.c wdt_kinetis.c
    ./: run_app_iar.s
  group app/flash_driver
    ../../flash_driver/: flash_FTFL.c
  group class
    ../../../../source/common/: usb_class.c
    ../../../../source/class/: usb_dfu.c usb_hid.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group prm
    config/: MKL25Z128VLK_Flash.icf
  group startup
    ./: cstartup_M.s low_level_init.c
