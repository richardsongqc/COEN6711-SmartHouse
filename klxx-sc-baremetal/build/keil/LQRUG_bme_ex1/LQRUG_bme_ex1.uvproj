# Keil uVision project LQRUG_bme_ex1.uvproj, settings and files
target KL25Z128 - Flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: LQRUG_bme_ex1_Flash +hex
  AfterMake: #K\ARM\ARMCC\bin\fromelf.exe --m32combined --output=.\UV4Build\@L.srec !L
  AfterMake: #K\ARM\ARMCC\bin\fromelf.exe --bincombined --output=.\UV4Build\@L.bin !L
  c flags: Optim=4
  c define: KEIL FREEDOM CMSIS
  c include: ..\..\..\src\projects\LQRUG_bme_ex1;..\..\..\src\common;..\..\..\src\cpu;..\..\..\src\cpu\headers\CMSIS\MKL25Z4\Include;..\..\..\src\drivers\llwu;..\..\..\src\drivers\lptmr;..\..\..\src\drivers\mcg;..\..\..\src\drivers\pmc;..\..\..\src\drivers\rcm;..\..\..\src\drivers\rtc;..\..\..\src\drivers\smc;..\..\..\src\drivers\uart;..\..\..\src\drivers\cmp;..\..\..\src\platforms;..\..;..\..\..\src\cpu\headers\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group project
    ../../../src/projects/LQRUG_bme_ex1/: LQRUG_bme_ex1.c systick.c systick.h
  group common
    ../../../src/common/: uif.c alloc.c assert.c io.c memtest.c queue.c stdlib.c
  group cpu
    ../../../src/cpu/: nmi_isr_handler.c start.c sysinit.c system_MKL25Z4.c startup_MKL25Z4.s arm_cm0.c
  group drivers
    ../../../src/drivers/cmp/: cmp.c
    ../../../src/drivers/llwu/: llwu.c
    ../../../src/drivers/lptmr/: lptmr.c
    ../../../src/drivers/mcg/: mcg.c
    ../../../src/drivers/pmc/: pmc.c
    ../../../src/drivers/rcm/: rcm.c
    ../../../src/drivers/rtc/: rtc.c
    ../../../src/drivers/smc/: smc.c
    ../../../src/drivers/uart/: uart.c Serial.c Retarget.c
  group platforms
    ../../../src/cpu/headers/CMSIS/MKL25Z4/Include/: MKL25Z4.h
    ../../../src/cpu/headers/CMSIS/: MemMapPtr_KL25Z4.h
    ../../../src/platforms/: freedom.h
