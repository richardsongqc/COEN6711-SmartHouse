# Keil uVision project twr-kl25Demo.uvproj, settings and files
target KL25Z128 - Flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: twr-kl25Demo_Flash
  AfterMake: #K\ARM\ARMCC\bin\fromelf.exe --m32combined --output=.\UV4Build\@L.srec !L
  AfterMake: #K\ARM\ARMCC\bin\fromelf.exe --bincombined --output=.\UV4Build\@L.bin !L
  c flags: Optim=1
  c define: KEIL TOWER CMSIS USB
  c include: ..\..\..\src\platforms;..\..\..\src\projects\twr-kl25Demo;..\..\..\src\common;..\..\..\src\cpu;..\..\..\src\cpu\headers\CMSIS\MKL25Z4\Include;..\..\..\src\drivers\llwu;..\..\..\src\drivers\lptmr;..\..\..\src\drivers\mcg;..\..\..\src\drivers\pmc;..\..\..\src\drivers\rcm;..\..\..\src\drivers\smc;..\..\..\src\drivers\uart;..\..\..\src\drivers\cmp;..\..\..\src\projects\twr-kl25Demo\adc_test;..\..\..\src\projects\twr-kl25Demo\adc16;..\..\..\src\projects\twr-kl25Demo\angle_calculation;..\..\..\src\projects\twr-kl25Demo\bsp;..\..\..\src\projects\twr-kl25Demo\dma;..\..\..\src\projects\twr-kl25Demo\gpio;..\..\..\src\projects\twr-kl25Demo\I2C;..\..\..\src\projects\twr-kl25Demo\rtc;..\..\..\src\projects\twr-kl25Demo\task_mgr;..\..\..\src\projects\twr-kl25Demo\TSI;..\..\..\src\projects\twr-kl25Demo\tsi_test;..\..\..\src\projects\twr-kl25Demo\usb;..\..\..\src\cpu\headers\CMSIS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group project
    ../../../src/projects/twr-kl25Demo/: twr-kl25Demo.c global.c pit.c sysinit.c
    ../../../src/projects/twr-kl25Demo/angle_calculation/: angle_cal.c asin.c median.c sqrt16.c
    ../../../src/projects/twr-kl25Demo/bsp/: bsp_KL25.c
    ../../../src/projects/twr-kl25Demo/gpio/: ROBOT_GPIO.c twr_kl25_gpio.c
    ../../../src/projects/twr-kl25Demo/I2C/: hal_dev_mma8451.c hal_i2c.c
    ../../../src/projects/twr-kl25Demo/rtc/: rtc.c
    ../../../src/projects/twr-kl25Demo/task_mgr/: task_mgr.c
    ../../../src/projects/twr-kl25Demo/TSI/: TSIDrv.c
    ../../../src/projects/twr-kl25Demo/usb/: ring_buffer.c usb.c usb_cdc.c usb_reg.c
    ../../../src/projects/twr-kl25Demo/adc_test/: adc_test.c
    ../../../src/projects/twr-kl25Demo/adc16/: adc16.c
  group common
    ../../../src/common/: uif.c alloc.c assert.c io.c memtest.c queue.c stdlib.c
  group cpu
    ../../../src/cpu/: nmi_isr_handler.c start.c system_MKL25Z4.c startup_MKL25Z4.s arm_cm0.c
  group drivers
    ../../../src/drivers/cmp/: cmp.c
    ../../../src/drivers/llwu/: llwu.c
    ../../../src/drivers/lptmr/: lptmr.c
    ../../../src/drivers/mcg/: mcg.c
    ../../../src/drivers/pmc/: pmc.c
    ../../../src/drivers/rcm/: rcm.c
    ../../../src/drivers/smc/: smc.c
    ../../../src/drivers/uart/: uart.c Serial.c Retarget.c
  group platforms
    ../../../src/platforms/: tower.h
    ../../../src/cpu/headers/CMSIS/: MemMapPtr_KL25Z4.h
    ../../../src/cpu/headers/CMSIS/MKL25Z4/Include/: MKL25Z4.h
