# IAR project low_power_demo_tower.ewp, settings and files
configuration FLASH_128KB (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TOWER; PERFORMANCE_RUN=1; ITERATIONS=400
  ICCARM.CCIncludePath2: ..\..\..\src\projects\low_power_demo; ..\..\..\src\projects\low_power_demo\BenchMark; ..\..\..\src\projects\low_power_demo\Kinetis; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\cmp; ..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: low_power_demo_tower.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_64KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\src\projects\low_power_demo; ..\..\..\src\projects\low_power_demo\CoreMark; ..\..\..\src\projects\low_power_demo\Kinetis; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\cmp; ..\..\..\src\platforms; ..\
  OBJCOPY.OOCOutputFile: low_power_demo_tower.srec
  ILINK.IlinkIcfFile: ..\config files\64KB_Pflash.icf
configuration FLASH_32KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: low_power_demo_tower.srec
  ILINK.IlinkIcfFile: ..\config files\32KB_Pflash.icf
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm0.c arm_cm0.h crt0.s nmi_isr_handler.c nmi_isr_handler.h start.c start.h sysinit.h vectors.c
    ../../../src/projects/low_power_demo/: sysinit.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MemMapPtr_KL25Z4.h MKL25Z4.h MKL25Z4_CMSIS.h
  group drivers/cmp
    ../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rtc
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group IAR
    ../../../src/projects/low_power_demo/: 128KB_Pflash.icf
    ../config files/: 32KB_Pflash.icf 64KB_Pflash.icf
    ../: iar.h
  group platforms
    ../../../src/projects/low_power_demo/: tower.h
  group project
    ../../../src/projects/low_power_demo/: isr.h low_power_demo.c low_power_demo.h
  group project/Kinetis
    ../../../src/projects/low_power_demo/Kinetis/: core_portme.c core_portme.h
