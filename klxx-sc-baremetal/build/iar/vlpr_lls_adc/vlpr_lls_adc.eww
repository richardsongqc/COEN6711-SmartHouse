<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\vlpr_lls_adc_freedom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\vlpr_lls_adc_tower.ewp</path>
  </project>
  <batchBuild/>
</workspace>


