# IAR project vlpr_lls_adc_freedom_CMSIS.ewp, settings and files
configuration RAM_4KB (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; FREEDOM
  ICCARM.CCIncludePath2: ..\..\..\src\projects\low_power_dma_uart_demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\cmp; ..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: platinum_freedom_CMSIS.out
  ILINK.IlinkIcfFile: ..\config files\4KB_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_8KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: ..\config files\8KB_RAM.icf
configuration RAM_16KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: ..\config files\16KB_RAM.icf
configuration FLASH_128KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  ICCARM.CCDefines: IAR; FREEDOM; CMSIS
  ICCARM.CCIncludePath2: ..\..\..\src\projects\vlpr_lls_adc; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\cpu\headers\CMSIS; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\cmp; ..\..\..\src\drivers\adc16; ..\
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: platinum_freedom_CMSIS.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
configuration FLASH_64KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: ..\config files\64KB_Pflash.icf
configuration FLASH_32KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: ..\config files\32KB_Pflash.icf
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../../src/cpu/: nmi_isr_handler.c nmi_isr_handler.h start.c start.h startup_MKL25Z4_iar.s sysinit.c sysinit.h system_MKL25Z4.c
  group cpu/headers
    ../../../src/cpu/headers/: MKL25Z128LK4.h
  group drivers/adc16
    ../../../src/drivers/adc16/: adc16.c adc16.h
  group drivers/cmp
    ../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rtc
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group IAR
    ../config files/: 128KB_Pflash.icf 16KB_RAM.icf 32KB_Pflash.icf 4KB_RAM.icf 64KB_Pflash.icf 8KB_RAM.icf
    ../: iar.h
  group platforms
    ../../../src/projects/vlpr_lls_adc/: freedom.h
  group project
    ../../../src/projects/vlpr_lls_adc/: isr.c isr.h vlpr_lls_adc.c
