# IAR project usb_host_tower.ewp, settings and files
configuration FLASH_128KB (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TOWER
  ICCARM.CCIncludePath2: ..\..\..\src\projects\usb_host; ..\..\..\src\projects\usb_host\bsp; ..\..\..\src\projects\usb_host\classes\common; ..\..\..\src\projects\usb_host\classes\hid; ..\..\..\src\projects\usb_host\classes\hub; ..\..\..\src\projects\usb_host\common; ..\..\..\src\projects\usb_host\driver; ..\..\..\src\projects\usb_host\host_common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\cmp; ..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usb_host_tower.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_64KB (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\config files\64KB_Pflash.icf
  group cpu
    ../../../src/cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MKL25Z128LK4.h
  group drivers/cmp
    ../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rtc
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group IAR
    ../config files/: 128KB_Pflash.icf 16KB_RAM.icf 32KB_Pflash.icf 4KB_RAM.icf 64KB_Pflash.icf 8KB_RAM.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: tower.h
  group project
    ../../../src/projects/usb_host/: hidmouse.c hidmouse.h isr.h sysinit.c tower.h
  group usb_host/bsp
    ../../../src/projects/usb_host/bsp/: bsp_KL25.c bsp_KL25.h
  group usb_host/classes/common
    ../../../src/projects/usb_host/classes/common/: usb_classes.c usb_classes.h
  group usb_host/classes/hid
    ../../../src/projects/usb_host/classes/hid/: usb_host_hid.c usb_host_hid.h
  group usb_host/classes/hub
    ../../../src/projects/usb_host/classes/hub/: usb_host_hub.c usb_host_hub.h usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h
  group usb_host/common
    ../../../src/projects/usb_host/common/: common.h fio.h io.c io.h rtc.c rtc.h startup.c startup.h write.c
  group usb_host/driver
    ../../../src/projects/usb_host/driver/: khci.c khci.h psptypes.h types.h usb.h usb_bsp.h usb_desc.h usbevent.c usbevent.h usbmsgq.c usbmsgq.h usbprv.h usbprv_host.h usbsem.c usbsem.h
  group usb_host/host_common
    ../../../src/projects/usb_host/host_common/: host_ch9.c host_ch9.h host_close.c host_close.h host_cnfg.h host_cnl.c host_cnl.h host_common.c host_common.h host_debug.h host_dev_list.c host_dev_list.h host_driver.c host_driver.h host_main.c host_main.h host_rcv.c host_rcv.h host_shut.c host_shut.h host_snd.c host_snd.h hostapi.h
