<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LQRUG_uart_ex2_freedom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\LQRUG_uart_ex2_tower.ewp</path>
  </project>
  <batchBuild/>
</workspace>


