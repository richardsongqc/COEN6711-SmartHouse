# IAR project twr-kl25Demo_tower.ewp, settings and files
configuration FLASH_128KB (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TOWER
  ICCARM.CCIncludePath2: ..\..\..\src\projects\twr-kl25Demo; ..\..\..\src\projects\twr-kl25Demo; ..\..\..\src\projects\twr-kl25Demo\bsp; ..\..\..\src\projects\twr-kl25Demo\usb; ..\..\..\src\projects\twr-kl25Demo\gpio; ..\..\..\src\projects\twr-kl25Demo\rtc; ..\..\..\src\projects\twr-kl25Demo\dma; ..\..\..\src\projects\twr-kl25Demo\adc16; ..\..\..\src\projects\twr-kl25Demo\adc_test; ..\..\..\src\projects\twr-kl25Demo\tsi; ..\..\..\src\projects\twr-kl25Demo\tsi_test; ..\..\..\src\projects\twr-kl25Demo\task_mgr; ..\..\..\src\projects\twr-kl25Demo\angle_calculation; ..\..\..\src\projects\twr-kl25Demo\i2c; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\adc16; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\sai; ..\..\..\src\drivers\smc; ..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: twr-kl25Demo_tower.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_64KB (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\config files\64KB_Pflash.icf
configuration FLASH_32KB (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\config files\32KB_Pflash.icf
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MKL25Z128LK4.h
  group drivers/cmp
    ../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group IAR
    ../config files/: 128KB_Pflash.icf 16KB_RAM.icf 32KB_Pflash.icf 4KB_RAM.icf 64KB_Pflash.icf 8KB_RAM.icf
    ../: iar.h
  group project
    ../../../src/projects/twr-kl25Demo/: global.c global.h isr.h pit.c pit.h sysinit.c tower.h twr-kl25Demo.c
  group project/adc16
    ../../../src/projects/twr-kl25Demo/adc16/: adc16.c adc16.h
  group project/adc_test
    ../../../src/projects/twr-kl25Demo/adc_test/: adc_test.c adc_test.h
  group project/angle_calculation
    ../../../src/projects/twr-kl25Demo/angle_calculation/: angle_cal.c angle_cal.h asin.c asin.h median.c median.h sqrt16.c sqrt16.h
  group project/bsp
    ../../../src/projects/twr-kl25Demo/bsp/: bsp_KL25.c bsp_KL25.h
  group project/i2c
    ../../../src/projects/twr-kl25Demo/I2C/: hal_dev_mma8451.c hal_dev_mma8451.h hal_i2c.c hal_i2c.h
  group project/rtc
    ../../../src/projects/twr-kl25Demo/rtc/: rtc.c rtc.h
  group project/task_mgr
    ../../../src/projects/twr-kl25Demo/task_mgr/: task_mgr.c task_mgr.h
  group project/tsi
    ../../../src/projects/twr-kl25Demo/TSI/: TSIDrv.c TSIDrv.h
  group project/twr_kl25_gpio
    ../../../src/projects/twr-kl25Demo/gpio/: twr_kl25_gpio.c twr_kl25_gpio.h
  group project/usb
    ../../../src/projects/twr-kl25Demo/usb/: ring_buffer.c ring_buffer.h usb.c usb.h usb_cdc.c usb_cdc.h usb_descriptor.h usb_reg.c usb_reg.h
